options:
  parameters:
    generate_options: qt_gui
    id: e206_test
    output_language: python
    title: E206 IQTAXI Test
  states: {}

blocks:
- name: bb_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 1000e3
    value: 100e3
  states: {}
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 70e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: tx_att
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: bb_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iqtaxi_rx_source_0
  id: iqtaxi_rx_source
  parameters:
    addr: '"192.168.1.11"'
    center_freq: lo_freq
    device: '"E206"'
    gain: rx_gain
    sample_rate: samp_rate
    samples_per_work: '4096'
  states: {}
- name: iqtaxi_tx_sink_0
  id: iqtaxi_tx_sink
  parameters:
    addr: '"192.168.1.11"'
    attenuation: tx_att
    center_freq: lo_freq
    device: '"E206"'
    sample_rate: samp_rate
    samples_per_packet: '4096'
    start_delay_ms: '0'
    timed: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', iqtaxi_tx_sink_0, '0']
- [iqtaxi_rx_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
